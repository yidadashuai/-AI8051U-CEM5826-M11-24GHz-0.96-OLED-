# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: project +hex
  group Source Group 1
    ./: main.c config.h font.h oled.c oled.h pic.h STC32G_Delay.h STC32G_GPIO.h STC32G_GPIO_Isr.c STC32G_I2C.c STC32G_I2C.h STC32G_I2C_Isr.c STC32G_Switch.h Type_def.h usart3.c usart3.h
    ../STC32G-SOFTWARE-LIB/library/: STC32G_Delay.c STC32G_GPIO.c
